# Keil uVision project PLC.uvprojx, settings and files
target PLC (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PLC_Config
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\MDK-ARM;..\Freemodbus\modbus\ascii;..\Freemodbus\modbus\functions;..\Freemodbus\modbus\include;..\Freemodbus\modbus\rtu;..\Freemodbus\modbus\tcp;..\Freemodbus\port;..\Freemodbus\modbus
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c threads.c freertos.c otherfunct.c periph.c pfc.c plc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c list.c timers.c queue.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Modbus/Port1
    ../Freemodbus/modbus/ascii/: mbascii.c
    ../Freemodbus/modbus/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ../Freemodbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
    ../Freemodbus/modbus/tcp/: mbtcp.c
    ../Freemodbus/modbus/: mb.c mb_m.c
    ../Freemodbus/port/: port.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c user_mb_app.c user_mb_app_m.c
