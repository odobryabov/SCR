# IAR project Discover.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: inc; ..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; C:\Users\Tech\Desktop\STM8L-Discovery\Project\Discover\src; C:\Users\Tech\Desktop\STM8L-Discovery\Project\Discover\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Discover.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L15X_MD; NDEBUG
  ICCSTM8.CCIncludePath2: inc; ..\..\Libraries\STM8L15x_StdPeriph_Driver\inc
  group STM8L15x_StdPeriph_Driver
    ../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c
  group User
    src/: delay.c discover_functions.c eeprom.c icc_measure.c main.c pfc.c stm8l15x_it.c stm8l_discovery_lcd.c
    ../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_dac.c
